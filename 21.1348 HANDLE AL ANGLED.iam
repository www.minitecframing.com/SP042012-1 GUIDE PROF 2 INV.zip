# Autodesk Inventor assembly: 21.1348 HANDLE AL ANGLED
## iProperties
Created: 2007-02
Part Number: 21.1348 HANDLE AL ANGLED
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
