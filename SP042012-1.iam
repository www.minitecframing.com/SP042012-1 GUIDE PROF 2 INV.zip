# Autodesk Inventor assembly: SP042012-1
## iProperties
Created: 2012-04
Part Number: SP042012-1
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
